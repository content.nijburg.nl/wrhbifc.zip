Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView], RevitIdentifiers [VersionGUID: 0f58afc0-bcb1-4fe6-a661-38b5a4e2447c, NumberOfSaves: 33]
File name: Project Number
Time: 2024-01-24T12:39:28+01:00
Written by: ODA SDAI 22.12
Made in: Autodesk Revit 23.1.30.97 (ENU) - IFC 23.3.1.0

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 415405; RefLongitude: -71, -3, -24, -318237; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcDistributionPort, OutPort_1965612_1
Description: Flow; FlowDirection: SOURCE

# IfcFlowTerminal: NLRS_57_AIR_UN_wall grill wrhb return LT_sacs:WRHBV, NLRS_57_AIR_UN_wall grill wrhb return LT_sacs:WRHBV:1965612
In: Default
Type - Description: Solid Air wall diffuser WRHB (return); PredefinedType: DIFFUSER; Material: NLRS_57_ral 9010_gen_sacs
Type - Other - Category: Air Terminals; Family Name: NLRS_57_AIR_UN_wall grill wrhb return LT_sacs; SACS_Base_Index: 2
Type - Constraints - Default Elevation: 0 mm
Type - General - FactorTable: WRH_Factors; LookupTable: WRHB
Type - Identity Data - Assembly Code: 57.0; Description: Solid Air wall diffuser WRHB (return); Manufacturer: Solid Air Climate Systems; Model: Wall diffuser; NLRS_C_content_creator: J. Feeke; NLRS_C_content_datum_uitgifte: 27-05-2021; NLRS_C_content_provider: Solid Air Climate Solutions; NLRS_C_content_versie: 3.18.01; NLRS_C_niveau ontwikkeling: LOD 400; OmniClass Number: 23.75.70.21.27.11; OmniClass Title: Diffusers, Registers, and Grilles; Type Name: WRHBV; URL: https://solid-air.com/products/air-diffusers/wall-and-transfer-diffusers/wall-diffusers/wtha-wrha
Type - Materials and Finishes - SACS_Material_Core: Steel; SACS_Material_Frame: Extruded Aluminium; SACS_Material_VCD: Extruded Aluminium
Type - Mechanical - Flow - Max Flow: 0 dm3/s; Min Flow: 0 dm3/s
Type - Visibility - SACS_Show_Symbol: no
Type - Pset_ManufacturerTypeInformation - Manufacturer: Solid Air Climate Systems
Classification: 57.0 Uniformat (Uniformat)
Pset_DistributionFlowElementCommon - Reference: WRHBV; sets with these values: 2
Other - Family: NLRS_57_AIR_UN_wall grill wrhb return LT_sacs; Family and Type: NLRS_57_AIR_UN_wall grill wrhb return LT_sacs: WRHBV; Type: WRHBV; Type Id: 1965548
Model Properties - Color Option (1-3): 1; SACS_Color_Ral: yes; SACS_Damper_Open_%: 100; SACS_Option_1: Flange 6mm; SACS_Option_2: Volume damper; SACS_Standard_Color: yes
Constraints - Elevation from Level: 0 mm; Offset from Host: 0 mm
Dimensions - Area: 2.87408 m2; NLRS_M_c01_breedte: 1225 mm; NLRS_M_c01_hoogte: 325 mm; SACS_Height: 325 mm; SACS_Width: 1225 mm; Volume: 0.00381927 m3
Identity Data - Mark: 8101; NLRS_C_description: Solid Air wall diffuser WRHB (return); NLRS_C_materiaal_kleur: RAL 9010 (standard); NLRS_C_model: WRHBVO 1225x325; SACS_Article_Code: 8301000920; SACS_Gross_Cost: 476; SACS_Price_Date: 44287
Materials and Finishes - SACS_Color: RAL 9010 (standard); SACS_Face_Color: NLRS_57_ral 9010_gen_sacs
Mechanical - NLRS_M_c01_drukverlies_statisch: 0 Pa; SACS_Max_Lp_dBA: 28; SACS_Max_Ploss: 15 Pa; System Classification: Return Air
Mechanical - Flow - Flow: 34.7222 dm3/s; NLRS_M_c01_debiet: 34.7222 dm3/s; SACS_Lp_dBA: 0; SACS_Nominal_Max_Flow: 1000 dm3/s; SACS_Nominal_Min_Flow: 600 dm3/s
Phasing - Phase Created: New Construction
Text - SACS_Warning_Text_Flow: Airflow over or below advised range
Visibility - SACS_Show_Arrows: yes; SACS_Warning_Disabled: no
